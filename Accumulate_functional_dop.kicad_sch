File: Accumulate_functional_dop.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: refactored
Other:
- note added: "Наружный шкаф"
- note removed: "к СХКВ"
